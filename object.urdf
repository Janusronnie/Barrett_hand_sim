Commit message: Add files via upload

File: object.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=object.obj scale=1 1 1; visual mesh filename=object.obj scale=1 1 1
